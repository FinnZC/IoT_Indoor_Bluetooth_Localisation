# IAR project IoTPhase1.ewp, settings and files
configuration IoTPhase1 (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; -DTOOLCHAIN_object; -DTARGET_MCU_NRF51822; --guard_calls; -DTARGET_NRF5; --preinclude=mbed_config.h; -DTARGET_MCU_NRF51822_UNIFIED; -DMBED_BUILD_TIMESTAMP=1524407720.08; -DDEVICE_SLEEP=1; -DTARGET_MCU_NORDIC_32K; -DTARGET_NRF51822; -DS130; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -DTARGET_MCU_NRF51_32K_UNIFIED; -e; -DTARGET_MCU_NRF51_UNIFIED; -DSOFTDEVICE_PRESENT; -DDEVICE_PWMOUT=1; -DDEVICE_I2C_ASYNCH=1; -DTARGET_FF_ARDUINO; -DTARGET_NORDIC; -DCMSIS_VECTAB_VIRTUAL; -DDEVICE_SPISLAVE=1; -DDEVICE_PORTOUT=1; -DTARGET_RELEASE; -DDEVICE_SERIAL_ASYNCH=1; -DDEVICE_SERIAL_FC=1; -DTARGET_LIKE_CORTEX_M0; -D__CORTEX_M0; -DDEVICE_ANALOGIN=1; -DTARGET_NRF51_DK; -DDEVICE_PORTIN=1; -DTARGET_CORTEX_M; -DTARGET_MCU_NRF51; -DDEVICE_I2C=1; -DBLE_STACK_SUPPORT_REQD; -DTARGET_CORTEX; -DDEVICE_LOWPOWERTIMER=1; -DDEVICE_INTERRUPTIN=1; -DNRF51; -DTARGET_SDK11; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DNO_SYSTICK; -DTARGET_LIKE_MBED; -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h"; -DTARGET_MCU_NRF51_32K; -DMBED_TICKLESS; -DDEVICE_SPI=1; -DARM_MATH_CM0; -D__MBED__=1; -DTOOLCHAIN_IAR; -DDEVICE_SERIAL=1; -DTARGET_M0; -D__CMSIS_RTOS; -DDEVICE_SPI_ASYNCH=1; -DFEATURE_BLE=1; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; source; mbed-os/.; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/mbedtls/targets; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/features/netsocket/cellular; mbed-os/features/netsocket/cellular/generic_modem_driver; mbed-os/features/filesystem; mbed-os/features/filesystem/bd; mbed-os/features/filesystem/fat; mbed-os/features/filesystem/fat/ChaN; mbed-os/features/filesystem/littlefs; mbed-os/features/filesystem/littlefs/littlefs; mbed-os/features/cellular; mbed-os/features/cellular/easy_cellular; mbed-os/features/cellular/framework; mbed-os/features/cellular/framework/API; mbed-os/features/cellular/framework/AT; mbed-os/features/cellular/framework/common; mbed-os/features/cellular/framework/targets; mbed-os/features/cellular/framework/targets/QUECTEL; mbed-os/features/cellular/framework/targets/QUECTEL/BC95; mbed-os/features/cellular/framework/targets/QUECTEL/BG96; mbed-os/features/cellular/framework/targets/TELIT; mbed-os/features/cellular/framework/targets/TELIT/HE910; mbed-os/features/cellular/framework/targets/UBLOX; mbed-os/features/cellular/framework/targets/UBLOX/LISA_U; mbed-os/features/lorawan; mbed-os/features/lorawan/lorastack; mbed-os/features/lorawan/lorastack/mac; mbed-os/features/lorawan/lorastack/phy; mbed-os/features/lorawan/system; mbed-os/features/nvstore; mbed-os/features/nvstore/source; mbed-os/cmsis; mbed-os/cmsis/TARGET_CORTEX_M; mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/TARGET_CORTEX; mbed-os/rtos/TARGET_CORTEX/rtx4; mbed-os/rtos/TARGET_CORTEX/rtx5; mbed-os/rtos/TARGET_CORTEX/rtx5/Include; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR; mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_M0; mbed-os/rtos/TARGET_CORTEX/rtx5/Source; mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M; mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_NORDIC; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_NRF51_DK; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/TOOLCHAIN_IAR; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/TOOLCHAIN_IAR/TARGET_MCU_NORDIC_32K; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/hex; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk_patch; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/rng; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/porting_tools; mbed-os/features/FEATURE_BLE; mbed-os/features/FEATURE_BLE/ble; mbed-os/features/FEATURE_BLE/ble/services; mbed-os/features/FEATURE_BLE/ble/generic; mbed-os/features/FEATURE_BLE/ble/pal; mbed-os/features/FEATURE_BLE/source; mbed-os/features/FEATURE_BLE/source/services; mbed-os/features/FEATURE_BLE/source/generic; mbed-os/features/FEATURE_BLE/targets; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/custom; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/common; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CORTEX_M0; -DTARGET_MCU_NRF51_32K; -DTARGET_MCU_NRF51822; -DTARGET_MCU_NORDIC_32K; -DSOFTDEVICE_PRESENT; -DNRF51; -DNO_SYSTICK; -DBLE_STACK_SUPPORT_REQD; -DTARGET_NRF51822; -DARM_MATH_CM0; -D__MBED_CMSIS_RTOS_CM; -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h"; -DCMSIS_VECTAB_VIRTUAL; -D__CMSIS_RTOS; -DMBED_TICKLESS; -DS130
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/TOOLCHAIN_IAR/TARGET_MCU_NORDIC_32K/nRF51822_QFAA.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    source/: NotifyArrayGattCharacteristic.h main.cpp
  group mbed-os
    mbed-os/: mbed.h
    mbed-os/features/frameworks/greentea-client/greentea-client/: test_env.h greentea_serial.h greentea_metrics.h
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h config-no-entropy.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h ssl.h ecp_internal.h net_sockets.h platform_time.h rsa_internal.h cmac.h ssl_cache.h
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/features/netsocket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h emac_stack_mem.h nsapi.h nsapi_dns.h nsapi_types.h CellularBase.h nsapi_ppp.h NetworkInterface.cpp NetworkStack.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp nsapi_dns.cpp
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.h PPPCellularInterface.h UARTCellularInterface.h OnboardCellularInterface.cpp PPPCellularInterface.cpp UARTCellularInterface.cpp
    mbed-os/features/filesystem/: Dir.h File.h FileSystem.h mbed_filesystem.h Dir.cpp File.cpp FileSystem.cpp
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.h HeapBlockDevice.h SlicingBlockDevice.h MBRBlockDevice.h ProfilingBlockDevice.h ExhaustibleBlockDevice.h ObservingBlockDevice.h ReadOnlyBlockDevice.h ChainingBlockDevice.cpp HeapBlockDevice.cpp SlicingBlockDevice.cpp MBRBlockDevice.cpp ProfilingBlockDevice.cpp ExhaustibleBlockDevice.cpp ObservingBlockDevice.cpp ReadOnlyBlockDevice.cpp
    mbed-os/features/filesystem/fat/: FATFileSystem.h FATFileSystem.cpp
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.h ffconf.h integer.h ff.cpp ffunicode.cpp
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.h LittleFileSystem.cpp
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.h lfs_util.h lfs.c lfs_util.c
    mbed-os/features/cellular/easy_cellular/: CellularConnectionFSM.h EasyCellularConnection.h APN_db.h CellularConnectionFSM.cpp EasyCellularConnection.cpp
    mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    mbed-os/features/cellular/framework/AT/: ATHandler.h AT_CellularBase.h AT_CellularDevice.h AT_CellularInformation.h AT_CellularNetwork.h AT_CellularPower.h AT_CellularSIM.h AT_CellularSMS.h AT_CellularStack.h ATHandler.cpp AT_CellularBase.cpp AT_CellularDevice.cpp AT_CellularInformation.cpp AT_CellularNetwork.cpp AT_CellularPower.cpp AT_CellularSIM.cpp AT_CellularSMS.cpp AT_CellularStack.cpp
    mbed-os/features/cellular/framework/common/: CellularList.h CellularLog.h CellularTargets.h CellularUtil.h CellularUtil.cpp
    mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularStack.h QUECTEL_BC95_CellularSIM.h QUECTEL_BC95.cpp QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularSIM.cpp
    mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.h QUECTEL_BG96.cpp QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularStack.cpp
    mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.h TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.h TELIT_HE910.cpp TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularPower.cpp
    mbed-os/features/cellular/framework/targets/UBLOX/LISA_U/: UBLOX_LISA_U.h UBLOX_LISA_U_CellularNetwork.h UBLOX_LISA_U_CellularPower.h UBLOX_LISA_U.cpp UBLOX_LISA_U_CellularNetwork.cpp UBLOX_LISA_U_CellularPower.cpp
    mbed-os/features/lorawan/: LoRaRadio.h LoRaWANBase.h LoRaWANInterface.h LoRaWANStack.h LoRaWANInterface.cpp LoRaWANStack.cpp
    mbed-os/features/lorawan/lorastack/mac/: LoRaMac.h LoRaMacChannelPlan.h LoRaMacCommand.h LoRaMacCrypto.h LoRaMacMcps.h LoRaMacMib.h LoRaMacMlme.h LoRaMac.cpp LoRaMacChannelPlan.cpp LoRaMacCommand.cpp LoRaMacCrypto.cpp LoRaMacMcps.cpp LoRaMacMib.cpp LoRaMacMlme.cpp
    mbed-os/features/lorawan/lorastack/phy/: LoRaPHY.h LoRaPHYAS923.h LoRaPHYAU915.h LoRaPHYCN470.h LoRaPHYCN779.h LoRaPHYEU433.h LoRaPHYEU868.h LoRaPHYIN865.h LoRaPHYKR920.h LoRaPHYUS915.h LoRaPHYUS915Hybrid.h lora_phy_ds.h LoRaPHY.cpp LoRaPHYAS923.cpp LoRaPHYAU915.cpp LoRaPHYCN470.cpp LoRaPHYCN779.cpp LoRaPHYEU433.cpp LoRaPHYEU868.cpp LoRaPHYIN865.cpp LoRaPHYKR920.cpp LoRaPHYUS915.cpp LoRaPHYUS915Hybrid.cpp
    mbed-os/features/lorawan/system/: LoRaWANTimer.h lorawan_data_structures.h LoRaWANTimer.cpp
    mbed-os/features/nvstore/source/: nvstore.h nvstore.cpp
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_compiler.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h MbedCRC.h SerialWireOutput.h TableCRC.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp RawSerial.cpp SPI.cpp Ticker.cpp Timer.cpp TimerEvent.cpp SPISlave.cpp UARTSerial.cpp Serial.cpp SerialBase.cpp MbedCRC.cpp TableCRC.cpp Timeout.cpp
    mbed-os/events/: Event.h EventQueue.h mbed_events.h mbed_shared_queues.h EventQueue.cpp mbed_shared_queues.cpp
    mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h EventFlags.h rtos_idle.h ConditionVariable.h Kernel.h Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp EventFlags.cpp ConditionVariable.cpp Kernel.cpp
    mbed-os/rtos/TARGET_CORTEX/: mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h SysTimer.h mbed_boot.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.h RTX_Config.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rt_OsEventObserver.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.h mbed_rtx_fault_handler.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h emac_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h flash_api.h critical_section_api.h itm_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_flash_api.c mbed_sleep_manager.c mbed_critical_section_api.c mbed_itm_api.c
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_preprocessor.h mbed_application.h mbed_critical.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_toolchain.h mbed_wait_api.h sleep.h ATCmdParser.h DirHandle.h FileBase.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h CriticalSectionLock.h DeepSleepLock.h mbed_poll.h FileHandle.h NonCopyable.h FileLike.h ScopedLock.h Stream.h mbed_mktime.h mbed_power_mgmt.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_application.c mbed_stats.c mbed_sdk_boot.c mbed_mktime.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_mem_trace.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp mbed_retarget.cpp ATCmdParser.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp Stream.cpp mbed_poll.cpp
    mbed-os/targets/TARGET_NORDIC/: mbed_rtx.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/: common_rtc.h gpio_object.h nrf5x_lf_clk_helper.h objects.h irq_handlers_hw.h gpio_api.c i2c_api.c lp_ticker.c nordic_critical.c pinmap.c port_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c reloc_vector_table.c flash_api.c trng_api.c itm_api.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/: PeripheralNames.h PortNames.h analogin_api.c pwmout_api.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_NRF51_DK/: PinNames.h device.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/: cmsis.h cmsis_nvic.h system_nrf51.h cmsis_nvic.c system_nrf51.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/: nrf_drv_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc/: nrf_drv_adc.h nrf_drv_adc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/: nrf_ble.h nrf_ble_err.h nrf_ble_gap.h nrf_ble_gatt.h nrf_ble_gattc.h nrf_ble_gatts.h nrf_ble_hci.h nrf_ble_l2cap.h nrf_ble_ranges.h nrf_ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51/: nrf_mbr.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk_patch/: sdk_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising/: ble_advertising.h ble_advertising.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery/: ble_db_discovery.h ble_db_discovery.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler/: ble_debug_assert_handler.h ble_debug_assert_handler.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm/: ble_dtm.h ble_dtm.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log/: ble_error_log.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp/: ble_racp.h ble_racp.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification/: ble_radio_notification.h ble_radio_notification.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu/: ble_dfu.h ble_dfu.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common/: ble_advdata.h ble_conn_params.h ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.h ble_advdata.c ble_conn_state.c ble_srv_common.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/: device_manager.h device_manager_peripheral.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config/: device_manager_cnfg.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager/: gatt_cache_manager.h gattc_cache_manager.h gatts_cache_manager.h id_manager.h peer_data.h peer_data_storage.h peer_database.h peer_id.h peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.h pm_mutex.h security_dispatcher.h security_manager.h gatt_cache_manager.c gattc_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf52.h nrf52_bitfields.h nrf52_name_change.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash/: ble_flash.h ble_flash.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock/: nrf_drv_clock.h nrf_drv_clock.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common/: nrf_drv_common.h nrf_drv_common.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config/: nrf_drv_config_validation.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay/: nrf_delay.h nrf_delay.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote/: nrf_drv_gpiote.h nrf_drv_gpiote.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal/: nrf_adc.h nrf_clock.h nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.h nrf_pdm.h nrf_ppi.h nrf_pwm.h nrf_rtc.h nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_uart.h nrf_wdt.h nrf_rng.h nrf_adc.c nrf_ecb.c nrf_nvmc.c nrf_saadc.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi/: nrf_drv_ppi.h nrf_drv_ppi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/: pstorage.h pstorage.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config/: pstorage_platform.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master/: nrf_drv_spi.h nrf_drv_spi.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave/: nrf_drv_spis.h nrf_drv_spis.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer/: nrf_drv_timer.h nrf_drv_timer.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/rng/: nrf_drv_rng.h nrf_drv_rng.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/: bootloader.h bootloader_settings.h bootloader_types.h bootloader_util.h dfu.h dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_transport.h dfu_types.h bootloader_util.c dfu_app_handler.c dfu_init_template.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h hci_transport_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16/: crc16.h crc16.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars/: section_vars.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/: fds.h fds_internal_defs.h fds.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config/: fds_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/: fstorage.h fstorage_internal_defs.h fstorage.c fstorage_nosd.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config/: fstorage_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/: hci_mem_pool.h hci_mem_pool.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config/: hci_mem_pool_internal.h hci_transport_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm/: app_pwm.h app_pwm.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler/: app_scheduler.h app_scheduler.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace/: app_trace.h app_trace.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util/: app_error.h app_error_weak.h app_util.h app_util_bds.h app_util_platform.h common.h nordic_common.h nrf_assert.h nrf_log.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.h sdk_os.h sdk_resources.h app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c sdk_mapped_flags.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler/: ant_stack_handler_types.h app_ram_base.h ble_stack_handler_types.h softdevice_handler.h softdevice_handler_appsh.h softdevice_handler.c softdevice_handler_appsh.c
    mbed-os/features/FEATURE_BLE/ble/: BLE.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h blecommon.h deprecate.h ArrayView.h BLETypes.h SafeEnum.h
    mbed-os/features/FEATURE_BLE/ble/services/: BatteryService.h DFUService.h DeviceInformationService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h LinkLossService.h UARTService.h URIBeaconConfigService.h iBeacon.h
    mbed-os/features/FEATURE_BLE/ble/generic/: GenericGattClient.h GenericGap.h GenericSecurityManager.h
    mbed-os/features/FEATURE_BLE/ble/pal/: AttClient.h AttClientToGattClientAdapter.h AttServerMessage.h EventQueue.h GapEvents.h GapTypes.h GenericAccessService.h PalGap.h PalGattClient.h SimpleAttServerMessage.h SimpleEventQueue.h ConnectionEventMonitor.h MemorySecurityDB.h PalSecurityManager.h SecurityDb.h
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/: nRF5XPalGattClient.h nRF5xGap.h nRF5xn.h nRF5xGattServer.h nRF5xSecurityManager.h projectconfig.h nRF5XPalGattClient.cpp nRF5xGattServer.cpp nRF5xn.cpp nRF5xGap.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/: btle.h btle_clock.h btle_security.h btle_gap.h btle.cpp btle_gap.cpp btle_security_pm.cpp btle_security.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/custom/: custom_helper.h custom_helper.cpp
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR/: cmain.S
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_M0/: irq_cm0.S
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR/: except.S
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/TOOLCHAIN_IAR/: startup_NRF51822_IAR.S
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c rsa_internal.c ssl_cookie.c ssl_ciphersuites.c ssl_cli.c ssl_tls.c ssl_srv.c ssl_ticket.c x509.c threading.c timing.c version.c version_features.c x509_crl.c x509_create.c x509_crt.c x509_csr.c ssl_cache.c x509write_crt.c x509write_csr.c xtea.c net_sockets.c sha512.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/mbedtls/targets/: hash_wrappers.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/features/frameworks/greentea-client/source/: greentea_test_env.cpp greentea_serial.cpp greentea_metrics.cpp
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_types.cpp utest_stack_trace.cpp
    mbed-os/features/FEATURE_BLE/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    mbed-os/features/FEATURE_BLE/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
    mbed-os/features/FEATURE_BLE/source/generic/: GenericGattClient.cpp GenericGap.cpp GenericSecurityManager.cpp
  group IoTPhase1
    ./: mbed_config.h
